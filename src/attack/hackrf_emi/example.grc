options:
  parameters:
    author: User
    generate_options: qt_gui
    id: example
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: '100000'
    step: '1000'
    stop: '5000000'
    value: '100000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    name: Transmit
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_1, '0']
- [soapy_hackrf_source_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
